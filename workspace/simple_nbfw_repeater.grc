options:
  parameters:
    author: OZ3RF
    generate_options: qt_gui
    id: simple_nbfm_repeater
    output_language: python
    title: Simple NBFM repeater
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: input_freq
  id: variable
  parameters:
    value: output_freq-2e6
  states: {}
- name: output_freq
  id: variable
  parameters:
    value: 434.8e6
  states: {}
- name: pa_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: PA Path
    label0: Auto
    label1: Band1
    label2: Band2
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '255'
  states: {}
- name: ppm
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: PPM
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: tone_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,3,1,1
    label: '"Modulated Tone"'
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: tone_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Tone offset
    min_len: '70'
    orient: Qt.Horizontal
    start: '-10e3'
    step: '1'
    stop: 10e3
    value: '1000'
  states: {state: disabled}
- name: variable_band_pass_filter_taps_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '2'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '100'
    samp_rate: audio_rate
    type: complex_band_pass
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '100.0'
    gate: 'True'
    len: int((samp_rate/10)  / 10)
    level: '0.01'
    ramp: int((samp_rate/10)  / 100)
    rate: samp_rate/10
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.0'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/10)
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-20'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '6'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '-2500'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '-2500'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tone_enable
    type: complex
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: gain
    oversample: '0'
    pa_path_ch0: pa_path
    rf_freq: output_freq + (input_freq/1e6*ppm)
    samp_rate: samp_rate
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: bandwidth
    gain_dB_ch0: '20'
    oversample: '0'
    rf_freq: input_freq + (input_freq/1e6*ppm)
    samp_rate: samp_rate
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / audio_rate
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,2,1,2
    legend: 'False'
    name: '"Output"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,2,1,2
    size: '10240'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: input_freq
    fftsize: '2048'
    gui_hint: 1,0,1,2
    name: '"Input"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: output_freq
    fftsize: '1024'
    gui_hint: 1,2,1,2
    name: '"Output"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    ant0: TX/RX
    center_freq0: output_freq + (input_freq/1e6*ppm)
    devname: uhd
    manual_gain0: 'False'
    overall_gain0: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    ant0: RX2
    balance0: '0'
    center_freq0: input_freq + (input_freq/1e6*ppm)
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=uhd
    devname: uhd
    overall_gain0: '10'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', qtgui_time_sink_x_0, '0']
- [analog_feedforward_agc_cc_0, '0', blocks_add_xx_0, '0']
- [analog_nbfm_rx_0, '0', analog_ctcss_squelch_ff_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', analog_nbfm_tx_0, '0']
- [band_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', limesdr_sink_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_add_xx_0, '0', soapy_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [limesdr_source_0, '0', band_pass_filter_0, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', band_pass_filter_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', band_pass_filter_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
