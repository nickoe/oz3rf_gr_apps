options:
  parameters:
    author: OZ3RF
    generate_options: qt_gui
    id: simple_nbfm_repeater
    output_language: python
    title: Simple NBFM repeater
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {state: disabled}
- name: input_freq
  id: variable
  parameters:
    value: output_freq-2e6
  states: {}
- name: output_freq
  id: variable
  parameters:
    value: 434.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: mmse_interpolator_xx_0
  id: mmse_interpolator_xx
  parameters:
    interp_ratio: samp_rate/audio_rate
    phase_shift: '0'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: input_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    ant0: Auto
    center_freq0: output_freq
    devname: lime
    iamp_gain0: '0'
    pad_gain0: '0'
    pga_gain0: '24'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: Auto
    balance0: '0'
    center_freq0: input_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: lime
    overall_gain0: '10'
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', mmse_interpolator_xx_0, '0']
- [analog_sig_source_x_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0, '0', soapy_sink_0, '0']
- [mmse_interpolator_xx_0, '0', blocks_add_xx_0, '1']
- [soapy_source_0, '0', blocks_add_xx_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_source_0, '0', soapy_sink_0, '0']

metadata:
  file_format: 1
